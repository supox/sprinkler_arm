# Keil uVision project TestPP.uvproj, settings and files
target Device (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TestPP
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group IOManagers
    ./: LedsManager.h LedsManager.cpp InputsManager.cpp InputsManager.h IInputListener.h
  group Main
    ./: main.cpp LedButtonListener.h
  group JSON
    ./: Json.h Json.cpp JsonParser.h JsonParser.cpp
  group Sprinkler
    ./: Sprinkler.cpp Sprinkler.h
  group Misc
    ./: Vector.h Config.h Logger.h Logger.cpp fputc_redirect.c List.h
  group Irrigation
    ./: Irrigation.cpp Irrigation.h IrrigationList.cpp IrrigationList.h IrrigationLogData.h
  group Alarm
    ./: Alarm.cpp Alarm.h
  group Sensors
    ./: Sensor.cpp Sensor.h SensorType.h SensorFactory.cpp SensorFactory.h WaterSensor.h WaterSensor.cpp MockSensor.cpp MockSensor.h BatterySensor.cpp BatterySensor.h ReadingData.h
  group Valf
    ./: Valf.cpp Valf.h ValvesManager.cpp ValvesManager.h
  group StringBuffer
    ./: StringBuffer.cpp StringBuffer.h text_buffer.c text_buffer.h
  group Tests
    ./: TestRTC.cpp TestJson.cpp TestSmartPointer.cpp TestTimeListenerData.cpp TestHelpers.cpp TestHelpers.h TestSensors.cpp TestValvesManager.cpp Tests.h TestHTTPParser.cpp TestGsmModem.cpp TestGsmStatusParser.cpp TestScheduler.cpp
  group Time
    ./: TimeListenersList.cpp TimeListenersList.h TimeManager.cpp TimeManager.h ITimeListener.h rtc_handler.cpp rtc_handler.h
  group Communication
    ./: Communication.cpp Communication.h I2CRoutines.h I2CRoutines.c http_parser.c http_parser.h HttpParser.cpp HttpParser.h GsmModem.h GsmModem.cpp GsmStatusParser.cpp GsmStatusParser.h
  group Perp_Library
    ./STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Scheduler
    ./: Scheduler.h Scheduler.cpp ITask.h
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: TestPP
  c flags: Optim=1
  c define: STM32F10X_MD _SIMULATOR USE_STDPERIPH_DRIVER _TESTS
  c include: .\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
